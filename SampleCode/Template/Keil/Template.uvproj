# Keil uVision project Template.uvproj, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO130KE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1EBFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x1ec00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c timer.c
  group User
    ../: main.c
